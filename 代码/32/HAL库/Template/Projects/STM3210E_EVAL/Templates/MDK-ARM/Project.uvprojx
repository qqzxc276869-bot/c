# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E_EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../../../../Drivers/CMSIS/Core/Include;../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM3210E_EVAL;../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c led.c key.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../Inc/: led.h key.h
  group Example/MDK-ARM
    ./: startup_stm32f103xg.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sd.c stm32f1xx_hal_uart.c stm32f1xx_hal_dac.c stm32f1xx_ll_usb.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_nand.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_nor.c stm32f1xx_hal_rtc.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_sram.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pccard.c stm32f1xx_hal_hcd.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_irda.c stm32f1xx_hal_adc.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2s.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal_cec.c
software components: CMSIS:CORE 4.3.0
